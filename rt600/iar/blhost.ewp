# IAR project blhost.ewp, settings and files
configuration RT700_firmware (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT685S_M33 NXP MIMXRT685S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; BOOTLOADER_HOST; _DLIB_FILE_DESCRIPTOR; MCU_IOSTREAM_SUPPORT=1; FILESYSTEM_ALT=1; RT700_BLINKY_IMAGE
  ICCARM.IExtraOptions: --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: ../source/mcux_config.h
  ICCARM.CCIncludePath2: ..; ../board; ../flash_config; ../CMSIS; ../CMSIS/m-profile; ../device; ../device/periph; ../drivers; ../utilities/debug_console_lite; ../utilities/str; ../component/uart; ../../src/; ../../src/include; ../../src/iostream; ../hostif
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: MCUXPRESSO_SDK; CPU_MIMXRT685SFVKB_cm33
  AARM.AUserIncludes: ..; ../../../flash_config; ../../../../../CMSIS/Core/Include; ../../../../../CMSIS/Core/Include/m-profile; ../../../../../devices/MIMXRT685S; ../../../../../devices/MIMXRT685S/periph; ../../../../../devices/MIMXRT685S/drivers; ../../../../../devices/MIMXRT685S/utilities/debug_console_lite; ../../../../../devices/MIMXRT685S/utilities/str; ../../../../../components/uart
  OBJCOPY.OOCOutputFile: blhost.bin
  ILINK.IlinkOutputFile: blhost_cm33.out
  ILINK.IlinkKeepSymbols: __image_bin
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration RT600_firmware (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; BOOTLOADER_HOST; _DLIB_FILE_DESCRIPTOR; MCU_IOSTREAM_SUPPORT=1; FILESYSTEM_ALT=1; RT600_BLINKY_IMAGE
  ILINK.IlinkKeepSymbols: __image_bin; __loader_bin
configuration RT500_firmware (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; SDK_DEBUGCONSOLE=0; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; BOOTLOADER_HOST; _DLIB_FILE_DESCRIPTOR; MCU_IOSTREAM_SUPPORT=1; FILESYSTEM_ALT=1; RT600_BLINKY_IMAGE
  ILINK.IlinkKeepSymbols: __image_bin; __loader_bin
  group blhost/blfwk
    ../../src/blfwk/: AESCounter.h AESKey.h BlfwkErrors.h Blob.h Bootloader.h bootloader_config.h BusPal.h BusPalPeripheral.h Command.h Crc.h DataSource.h DataSourceImager.h DataTarget.h ELF.h ELFSourceFile.h EndianUtilities.h ExcludesListMatcher.h format_string.h GHSSecInfo.h GlobMatcher.h HexValues.h hidapi.h host_types.h i2c.h I2cPeripheral.h int_size.h IntelHexSourceFile.h json.h Logging.h LpcUsbSio.h LpcUsbSioPeripheral.h OptionContext.h options.h Packetizer.h Peripheral.h Progress.h Random.h rijndael.h RijndaelCTR.h SBSourceFile.h SDPCommand.h SDPUartPacketizer.h SDPUsbHidPacketizer.h SearchPath.h serial.h SerialPacketizer.h SimPacketizer.h SimPeripheral.h Simulator.h SimulatorMemory.h smart_ptr.h SourceFile.h spi.h SpiPeripheral.h SRecordSourceFile.h stdafx.h StELFFile.h StExecutableImage.h StIntelHexFile.h StringMatcher.h StSRecordFile.h UartPeripheral.h Updater.h UsbHidPacketizer.h UsbHidPeripheral.h utils.h Value.h
  group blhost/blfwk/src
    ../../src/blfwk/src/: AESCounter.cpp AESKey.cpp Blob.cpp Bootloader.cpp BusPal.cpp BusPalPeripheral.cpp Command.cpp Crc.cpp DataSource.cpp DataSourceImager.cpp DataTarget.cpp ELFSourceFile.cpp ExcludesListMatcher.cpp format_string.cpp GHSSecInfo.cpp GlobMatcher.cpp HexValues.cpp I2cPeripheral.cpp IntelHexSourceFile.cpp jsoncpp.cpp Logging.cpp LpcUsbSio.cpp LpcUsbSioPeripheral.cpp options.cpp Random.cpp rijndael.cpp RijndaelCTR.cpp SBSourceFile.cpp SDPCommand.cpp SDPUsbHidPacketizer.cpp SearchPath.cpp SerialPacketizer.cpp SourceFile.cpp SpiPeripheral.cpp SRecordSourceFile.cpp StELFFile.cpp StExecutableImage.cpp StIntelHexFile.cpp StSRecordFile.cpp UartPeripheral.cpp Updater.cpp UsbHidPacketizer.cpp UsbHidPeripheral.cpp utils.cpp Value.cpp
  group blhost/bootloader
    ../../src/bootloader/: bl_peripheral.h
  group blhost/crc
    ../../src/crc/src/: crc16.c crc32.c
  group blhost/iostream
    ../../src/iostream/: Filesystem_alt.c Filesystem_alt.h MCUiostream.h
  group board
    ../board/: app.h board.c board.h clock_config.c clock_config.h hardware_init.c pin_mux.c pin_mux.h
  group CMSIS
    ../CMSIS/: cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../CMSIS/m-profile/: armv8m_mpu.h cmsis_iccarm_m.h
  group component/uart
    ../component/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group device
    ../device/: fsl_device_registers.h MIMXRT685S_cm33.h MIMXRT685S_cm33_COMMON.h MIMXRT685S_cm33_features.h system_MIMXRT685S_cm33.c system_MIMXRT685S_cm33.h
  group device/periph
    ../device/periph/: PERI_ADC.h PERI_AHB_SECURE_CTRL.h PERI_CACHE64_CTRL.h PERI_CACHE64_POLSEL.h PERI_CASPER.h PERI_CLKCTL0.h PERI_CLKCTL1.h PERI_CMP.h PERI_CRC.h PERI_CTIMER.h PERI_DMA.h PERI_DMIC.h PERI_FLEXCOMM.h PERI_FLEXSPI.h PERI_FREQME.h PERI_GPIO.h PERI_HASHCRYPT.h PERI_I2C.h PERI_I2S.h PERI_I3C.h PERI_INPUTMUX.h PERI_IOPCTL.h PERI_MRT.h PERI_MU.h PERI_OCOTP.h PERI_OSTIMER.h PERI_OTFAD.h PERI_PINT.h PERI_PMC.h PERI_POWERQUAD.h PERI_PUF.h PERI_RSTCTL0.h PERI_RSTCTL1.h PERI_RTC.h PERI_SCT.h PERI_SEMA42.h PERI_SPI.h PERI_SYSCTL0.h PERI_SYSCTL1.h PERI_TRNG.h PERI_USART.h PERI_USBHSD.h PERI_USBHSDCD.h PERI_USBHSH.h PERI_USBPHY.h PERI_USDHC.h PERI_UTICK.h PERI_WWDT.h
  group drivers
    ../drivers/: fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_dsp.c fsl_dsp.h fsl_flexcomm.c fsl_flexcomm.h fsl_flexspi.c fsl_flexspi.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_i2s_bridge.c fsl_i2s_bridge.h fsl_inputmux_connections.h fsl_iopctl.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_spi.c fsl_spi.h fsl_usart.c fsl_usart.h
  group flash_config
    ../flash_config/: flash_config.c flash_config.h
  group hostif
    ../hostif/: host_i2c.c host_serial.c host_spi.c host_time.c host_usbhid.c mcu_system.h
  group source
    ../../tools/blhost/src/: blhost.cpp
    ../source/: blhost_app.c mcux_config.h
  group startup/iar
    ./: startup_MIMXRT685S_cm33.s
  group utilities
    ../utilities/: fsl_assert.c fsl_assert.h
  group utilities/debug_console_lite
    ../utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h
  group utilities/str
    ../utilities/str/: fsl_str.c fsl_str.h
