# IAR project blhost.ewp, settings and files
configuration RT600_firmware (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1189xxx8_M33 NXP MIMXRT1189xxx8_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1189CVM8C_cm33; MIMXRT1189_cm33_SERIES; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; BOOTLOADER_HOST; _DLIB_FILE_DESCRIPTOR; MCU_IOSTREAM_SUPPORT=1; FILESYSTEM_ALT=1; RT600_BLINKY_IMAGE
  ICCARM.IExtraOptions: --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: ../source/mcux_config.h
  ICCARM.CCIncludePath2: ..; ../board; ../xip; ../CMSIS; ../CMSIS/m-profile; ../device; ../device/periph; ../drivers; ../utilities/debug_console_lite; ../utilities/str; ../component/uart; ../component/silicon_id; ../component/silicon_id/socs; ../../src/; ../../src/include; ../../src/iostream; ../hostif
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: MCUXPRESSO_SDK; CPU_MIMXRT1189CVM8C_cm33; MIMXRT1189_cm33_SERIES
  AARM.AUserIncludes: ..; ../board; ../xip; ../CMSIS; ../CMSIS/m-profile; ../device; ../device/periph; ../drivers; ../utilities/debug_console_lite; ../utilities/str; ../component/uart; ../component/silicon_id; ../component/silicon_id/socs
  OBJCOPY.OOCOutputFile: blhost.bin
  ILINK.IlinkOutputFile: blhost_cm33.out
  ILINK.IlinkKeepSymbols: __image_bin
  ILINK.IlinkIcfFile: MIMXRT1189xxxxx_cm33_flexspi_nor.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group blhost/blfwk
    ../../src/blfwk/: AESCounter.h AESKey.h BlfwkErrors.h Blob.h Bootloader.h bootloader_config.h BusPal.h BusPalPeripheral.h Command.h Crc.h DataSource.h DataSourceImager.h DataTarget.h ELF.h ELFSourceFile.h EndianUtilities.h ExcludesListMatcher.h format_string.h GHSSecInfo.h GlobMatcher.h HexValues.h hidapi.h host_types.h i2c.h I2cPeripheral.h int_size.h IntelHexSourceFile.h json.h Logging.h LpcUsbSio.h LpcUsbSioPeripheral.h OptionContext.h options.h Packetizer.h Peripheral.h Progress.h Random.h rijndael.h RijndaelCTR.h SBSourceFile.h SDPCommand.h SDPUartPacketizer.h SDPUsbHidPacketizer.h SearchPath.h serial.h SerialPacketizer.h SimPacketizer.h SimPeripheral.h Simulator.h SimulatorMemory.h smart_ptr.h SourceFile.h spi.h SpiPeripheral.h SRecordSourceFile.h stdafx.h StELFFile.h StExecutableImage.h StIntelHexFile.h StringMatcher.h StSRecordFile.h UartPeripheral.h Updater.h UsbHidPacketizer.h UsbHidPeripheral.h utils.h Value.h
  group blhost/blfwk/src
    ../../src/blfwk/src/: AESCounter.cpp AESKey.cpp Blob.cpp Bootloader.cpp BusPal.cpp BusPalPeripheral.cpp Command.cpp Crc.cpp DataSource.cpp DataSourceImager.cpp DataTarget.cpp ELFSourceFile.cpp ExcludesListMatcher.cpp format_string.cpp GHSSecInfo.cpp GlobMatcher.cpp HexValues.cpp I2cPeripheral.cpp IntelHexSourceFile.cpp jsoncpp.cpp Logging.cpp LpcUsbSio.cpp LpcUsbSioPeripheral.cpp options.cpp Random.cpp rijndael.cpp RijndaelCTR.cpp SBSourceFile.cpp SDPCommand.cpp SDPUsbHidPacketizer.cpp SearchPath.cpp SerialPacketizer.cpp SourceFile.cpp SpiPeripheral.cpp SRecordSourceFile.cpp StELFFile.cpp StExecutableImage.cpp StIntelHexFile.cpp StSRecordFile.cpp UartPeripheral.cpp Updater.cpp UsbHidPacketizer.cpp UsbHidPeripheral.cpp utils.cpp Value.cpp
  group blhost/bootloader
    ../../src/bootloader/: bl_peripheral.h
  group blhost/crc
    ../../src/crc/src/: crc16.c crc32.c
  group blhost/iostream
    ../../src/iostream/: Filesystem_alt.c Filesystem_alt.h MCUiostream.h
  group board
    ../board/: app.h board.c board.h clock_config.c clock_config.h hardware_init.c pin_mux.c pin_mux.h
  group CMSIS
    ../CMSIS/: cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../CMSIS/m-profile/: armv8m_mpu.h cmsis_iccarm_m.h
  group component/silicon_id
    ../component/silicon_id/: fsl_silicon_id.c fsl_silicon_id.h
    ../component/silicon_id/socs/imxrt1180/: fsl_silicon_id_soc.c
    ../component/silicon_id/socs/: fsl_silicon_id_soc.h
  group component/uart
    ../component/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    ../device/: fsl_device_registers.h MIMXRT1189_cm33.h MIMXRT1189_cm33_COMMON.h MIMXRT1189_cm33_features.h system_MIMXRT1189_cm33.c system_MIMXRT1189_cm33.h
  group device/periph
    ../device/periph/: PERI_ADC.h PERI_ANADIG.h PERI_ANADIG_LDO_BBSM.h PERI_ANADIG_MISC.h PERI_ANADIG_OSC.h PERI_ANADIG_PLL.h PERI_ANADIG_PMU.h PERI_ANADIG_TEMPSENSOR.h PERI_AOI.h PERI_ASRC.h PERI_AXBS.h PERI_BBNSM.h PERI_BLK_CTRL_BBSMMIX.h PERI_BLK_CTRL_NS_AONMIX.h PERI_BLK_CTRL_S_AONMIX.h PERI_BLK_CTRL_WAKEUPMIX.h PERI_CACHE_ECC_MCM.h PERI_CAN.h PERI_CCM.h PERI_CMP.h PERI_DAC.h PERI_DCDC.h PERI_DMA.h PERI_DMA4.h PERI_ECAT.h PERI_EIM.h PERI_ENETC_GLOBAL.h PERI_ENETC_PCI_TYPE0.h PERI_ENETC_PF_EMDIO.h PERI_ENETC_PF_TMR.h PERI_ENETC_SI.h PERI_ENETC_VF_PCI_TYPE0.h PERI_EQDC.h PERI_ERM.h PERI_EWM.h PERI_FLEXIO.h PERI_FLEXSPI.h PERI_FLEXSPI_SLV.h PERI_GPC_CPU_CTRL.h PERI_GPC_GLOBAL.h PERI_GPC_SYS_SLEEP_CTRL.h PERI_GPT.h PERI_I2S.h PERI_I3C.h PERI_IEE.h PERI_IEE_APC.h PERI_IERC_IERB.h PERI_IERC_PCI.h PERI_IOMUXC.h PERI_IOMUXC_AON.h PERI_KPP.h PERI_LPI2C.h PERI_LPIT.h PERI_LPSPI.h PERI_LPTMR.h PERI_LPUART.h PERI_M7_MCM.h PERI_MECC.h PERI_MSGINTR.h PERI_MU.h PERI_NETC_ENETC.h PERI_NETC_ETH_LINK.h PERI_NETC_IERB.h PERI_NETC_PORT.h PERI_NETC_PRIV.h PERI_NETC_PSEUDO_LINK.h PERI_NETC_SW.h PERI_NETC_SW_ENETC.h PERI_OCOTP_FSB.h PERI_OSC_RC_400M.h PERI_OTFAD.h PERI_PDM.h PERI_PHY_LDO.h PERI_PLL.h PERI_PWM.h PERI_RGPIO.h PERI_RTWDOG.h PERI_S3MU.h PERI_SEMA42.h PERI_SEMC.h PERI_SINC.h PERI_SPDIF.h PERI_SRC_GENERAL.h PERI_SRC_MIF_LN28FDSOI_SPLLRAM.h PERI_SRC_MIF_S28SPREGH.h PERI_SRC_MIF_S28SPREGH_PSWA.h PERI_SRC_MIX_SLICE.h PERI_SYS_CTR_COMPARE.h PERI_SYS_CTR_CONTROL.h PERI_SYS_CTR_READ.h PERI_SYSPM.h PERI_TCM_ECC_MCM.h PERI_TMPSNS.h PERI_TMR.h PERI_TPM.h PERI_TRDC.h PERI_TSTMR.h PERI_USB.h PERI_USBHSDCD.h PERI_USBNC.h PERI_USBPHY.h PERI_USDHC.h PERI_VMBANDGAP.h PERI_VREF.h PERI_XBAR_NUM_OUT221.h PERI_XBAR_NUM_OUT32.h PERI_XCACHE.h
  group drivers
    ../drivers/: fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_dcdc.c fsl_dcdc.h fsl_ele_base_api.c fsl_ele_base_api.h fsl_gpc.c fsl_gpc.h fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart.c fsl_lpuart.h fsl_memory.c fsl_memory.h fsl_misc.h fsl_pmu.c fsl_pmu.h fsl_rgpio.c fsl_rgpio.h fsl_s3mu.c fsl_s3mu.h fsl_soc_src.c fsl_soc_src.h fsl_trdc.c fsl_trdc.h
  group hostif
    ../hostif/: host_i2c.c host_serial.c host_spi.c host_time.c host_usbhid.c mcu_system.h
  group source
    ../../tools/blhost/src/: blhost.cpp
    ../source/: blhost_app.c mcux_config.h
  group startup/iar
    ./: startup_MIMXRT1189_cm33.s
  group utilities
    ../utilities/: fsl_assert.c fsl_assert.h
  group utilities/debug_console_lite
    ../utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h
  group utilities/str
    ../utilities/str/: fsl_str.c fsl_str.h
  group xip
    ../xip/: evkmimxrt1180_flexspi_nor_config.c evkmimxrt1180_flexspi_nor_config.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
